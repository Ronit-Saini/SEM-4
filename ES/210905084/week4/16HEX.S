	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
NUM EQU 0xFFFF
	MOV R2, #0
	MOV R3, #0
	MOV R4, #0
	MOV R5, #0
	LDR R1, =NUM
LOOP
    CMP R1,#10000
	BLT NEXT
	SUB R1,R1,#10000
	ADD R2,R2,#1
	B LOOP
NEXT
    CMP R1,#1000
	BLT NEXT1
	SUB R1,R1,#1000
	ADD R3,R3,#1
	B NEXT
NEXT1
    CMP R1,#100
	BLT NEXT2
	SUB R1,R1,#100
	ADD R4,R4,#1
	B NEXT1
NEXT2
    CMP R1,#10
	BLT NEXT3
	SUB R1,R1,#10
	ADD R5,R5,#1
	B NEXT2
NEXT3
    LDR R6,=RESULT
	ADD R1,R4,LSL#4
	ADD R3,R2,LSL#4
	STRB R1,[R6], #1
	STRB R3,[R6]
STOP
    B STOP

	AREA mydata, DATA, READWRITE
RESULT DCD 0
	END